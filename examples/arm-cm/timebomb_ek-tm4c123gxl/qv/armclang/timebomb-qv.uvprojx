# Keil uVision project timebomb-qv.uvprojx, settings and files
target qpm (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: EK_TM4C123GXL
  c include: ..\..\;\qp\qpm\include;\qp\qpm\src;\qp\qpm\ports\arm-cm\qv\armclang;\qp\qpm\3rd_party\CMSIS\Include;\qp\qpm\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group ek-tm4c123gxl
    /qp/qpm/3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
    ../../../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c
  group QPM
    C:/qp/qpm/src/qfn/: qfn.c
    C:/qp/qpm/ports/arm-cm/qv/armclang/: qvn_port.c
    C:/qp/qpm/src/qvn/: qvn.c
    ../: bsp.c
    ../../: main.c
    ../../../../../src/qfn/: Hsm.c
